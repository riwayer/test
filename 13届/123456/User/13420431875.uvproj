# Keil uVision project 13420431875.uvproj, settings and files
target 13420431875 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 13420431875 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: define.h ds1302.c Init.c Init.h Key.c Key.h Led.c Led.h onewire.c Seg.c Seg.h Ds18b20.h ds1302.h
